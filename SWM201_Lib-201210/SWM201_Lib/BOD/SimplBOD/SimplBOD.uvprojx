# Keil uVision project SimplBOD.uvprojx, settings and files
target SWM201 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: SimplBOD
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c include: ..\..\SWM201_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM201_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM201_StdPeriph_Driver\CSL\SWM201_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ../../SWM201_StdPeriph_Driver/CSL/SWM201_StdPeriph_Driver/: SWM201_adc.c SWM201_exti.c SWM201_gpio.c SWM201_i2c.c SWM201_pwm.c SWM201_timr.c SWM201_uart.c SWM201_wdt.c SWM201_flash.c SWM201_port.c SWM201_rtc.c
  group CSL\CMSIS
    ../../SWM201_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM201.c
    ../../SWM201_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM201.s
software components: CMSIS:CORE 5.3.0
