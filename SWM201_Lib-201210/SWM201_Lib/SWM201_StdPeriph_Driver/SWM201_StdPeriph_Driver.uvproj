# Keil uVision project SWM201_StdPeriph_Driver.uvproj, settings and files
target SWM201 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: SWM201_stdperiph_lib
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2
  c include: .\CSL\CMSIS\CoreSupport;.\CSL\CMSIS\DeviceSupport;.\CSL\SWM201_StdPeriph_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./app/: main.c
  group CSL\StdPD
    ./CSL/SWM201_StdPeriph_Driver/: SWM201_port.c SWM201_gpio.c SWM201_exti.c SWM201_timr.c SWM201_uart.c SWM201_adc.c SWM201_i2c.c SWM201_pwm.c SWM201_flash.c SWM201_rtc.c SWM201_wdt.c SWM201_sleep.c SWM201_div.c SWM201_cordic.c
  group CSL\CMSIS
    ./CSL/CMSIS/DeviceSupport/: system_SWM201.c
    ./CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM201.s
