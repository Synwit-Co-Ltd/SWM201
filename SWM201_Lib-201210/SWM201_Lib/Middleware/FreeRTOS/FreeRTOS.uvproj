# Keil uVision project FreeRTOS.uvproj, settings and files
target SWM201 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: FreeRTOS
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2
  c include: ..\..\SWM201_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM201_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM201_StdPeriph_Driver\CSL\SWM201_StdPeriph_Driver;.\APP\FreeRTOS;.\APP\FreeRTOS\port_MDK
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group APP
    ./app/: main.c
  group FreeRTOS
    ./APP/FreeRTOS/: list.c queue.c tasks.c
    ./APP/FreeRTOS/heap/: heap_1.c
    ./APP/FreeRTOS/port_MDK/: port.c
  group CSL\StdPD
    ../../SWM201_StdPeriph_Driver/CSL/SWM201_StdPeriph_Driver/: SWM201_adc.c SWM201_exti.c SWM201_gpio.c SWM201_i2c.c SWM201_pwm.c SWM201_timr.c SWM201_uart.c SWM201_wdt.c SWM201_flash.c SWM201_port.c SWM201_rtc.c
  group CSL\CMSIS
    ../../SWM201_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM201.c
    ../../SWM201_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM201.s
